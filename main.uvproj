# Keil uVision project main.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: main +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\lib;.\user\inc
  group lib
    ./lib/: stc8.h
  group inc
    ./user/inc/: config.h delay.h type.h io.h key.h main.h usart.h
  group src
    ./user/src/: delay.c main.c io.c key.c usart.c
